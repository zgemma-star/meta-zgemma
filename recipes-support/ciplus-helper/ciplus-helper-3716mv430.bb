SRCDATE = "20211026"

require ciplus-helper.inc

SRC_URI[md5sum] = "8938ae317ae2da83516df0bb23db43cf"
SRC_URI[sha256sum] = "cc55c6e0b67ea3fe947a25bd57ff48c42102563c61af6fccae60b2d22c06b24b"
