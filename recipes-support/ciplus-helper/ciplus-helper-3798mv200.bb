SRCDATE = "20200625"

require ciplus-helper.inc

SRC_URI[md5sum] = "ff1fb9dc4bdae579b4a0e8909defd9c2"
SRC_URI[sha256sum] = "6837fc89aecf6d7d995c2762df8b3a7c9dc7e49ddfe8b10ce00c4bf94cad86e4"
