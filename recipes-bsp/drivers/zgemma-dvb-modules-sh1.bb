KV = "4.0.1"
SRCDATE = "20151211"

require zgemma-dvb-modules.inc

SRC_URI[md5sum] = "6b5fe5fa4b3e53fb06a1baf056eb6a78"
SRC_URI[sha256sum] = "767d458a09f563a58230af35c3cda3c40e2a74e392590539db5448c66b076882"

COMPATIBLE_MACHINE = "sh1"