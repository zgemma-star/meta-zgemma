SRCDATE = "20210914"

require zgemma-libs.inc

SRC_URI[md5sum] = "dce11616c14904fc6a0a27922eb94233"
SRC_URI[sha256sum] = "f2bb86baf96380651cff271d324e4084f97ba35d534973036199d0ccff9dfeb4"

COMPATIBLE_MACHINE = "^hzero$|^h8$"
