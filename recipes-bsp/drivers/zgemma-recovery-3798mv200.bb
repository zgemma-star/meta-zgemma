SRCDATE = "20201104"

require zgemma-recovery.inc

SRC_URI[md5sum] = "0ae2d3c8be86fa6c807a517c4ea6dbe0"
SRC_URI[sha256sum] = "08dcf21d5bada7b134b43bfdaa15204468f19d2cfd2e3df19695094e654d4dab"

COMPATIBLE_MACHINE = "^h9se$|^h9combo$|^h9combose$|^h10$|^i55se$"
