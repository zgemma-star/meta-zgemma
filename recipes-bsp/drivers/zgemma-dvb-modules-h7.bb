KV = "4.10.12"
SRCDATE = "20180411"

require zgemma-dvb-modules.inc

SRC_URI[arm.md5sum] = "32beb1663ab27c9313a71611f4624f40"
SRC_URI[arm.sha256sum] = "102caf4bcc2163f692a5afb1cab5403f7d0a6fb96583e799112291ae24af822f"

COMPATIBLE_MACHINE = "h7"