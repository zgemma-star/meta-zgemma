SRCDATE = "20200508"

require zgemma-fastboot.inc

SRC_URI[md5sum] = ""
SRC_URI[sha256sum] = ""

COMPATIBLE_MACHINE = "hzero"
