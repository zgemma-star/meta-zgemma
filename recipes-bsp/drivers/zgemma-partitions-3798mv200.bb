SRCDATE = "20180830"

require zgemma-partitions.inc

SRC_URI[md5sum] = "7df489d1afe861011b60762005a34534"
SRC_URI[sha256sum] = "1a6c640a019c483b28e21bafba0d4b0f9467c7554c504d6312a8e33897d17ac2"

COMPATIBLE_MACHINE = "h9|i55plus"