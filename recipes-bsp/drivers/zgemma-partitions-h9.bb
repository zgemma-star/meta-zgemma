SRCDATE = "20180219"

require zgemma-partitions.inc

SRC_URI[md5sum] = "8eacdc923f6031aa3886eb9a5fe1e15a"
SRC_URI[sha256sum] = "f7b730d2c16bc80560089ed410c6b5ce76a336041c92e467f994828d8d5e697b"

COMPATIBLE_MACHINE = "h9"