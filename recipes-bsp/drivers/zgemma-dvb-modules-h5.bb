KV = "4.10.12"
SRCDATE = "20180830"

require zgemma-dvb-modules.inc

SRC_URI[mips.md5sum] = "2ce6c030f5d7030b9ec6a678d2b6e052"
SRC_URI[mips.sha256sum] = "6d16152635835c8bdb8e2864ca37d004815081a5a97a998efefb59c54c31bd94"

COMPATIBLE_MACHINE = "h5"