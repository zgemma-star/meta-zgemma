SRCDATE = "20170317"

require zgemma-v3ddriver.inc

SRC_URI[md5sum] = "0ff258c1910d9d301f00f6a51e6938d8"
SRC_URI[sha256sum] = "9774f40278ef9f5ade3c06b8b6c584b4f226729c067af45bf7d0ef1b6d27487e"

COMPATIBLE_MACHINE = "h7"