KV = "4.10.12"
SRCDATE = "20180411"

require zgemma-dvb-modules.inc

SRC_URI[mips.md5sum] = "d4176d294e7942ed5a8ee8cb4d88295b"
SRC_URI[mips.sha256sum] = "2f43de820f459695f2c0b4e62fe5d904f76645ae78571568c75a1b6e8aee2f06"

COMPATIBLE_MACHINE = "i55"