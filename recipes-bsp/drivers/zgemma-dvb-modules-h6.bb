KV = "4.10.12"
SRCDATE = "20171108"

require zgemma-dvb-modules.inc

SRC_URI[mips.md5sum] = "532d98a427c0cf11ca10c16a46288c9d"
SRC_URI[mips.sha256sum] = "e379ef48df8986c54dcf8fa16973cb152e76beae7718440729418db5261051ba"

COMPATIBLE_MACHINE = "h6"