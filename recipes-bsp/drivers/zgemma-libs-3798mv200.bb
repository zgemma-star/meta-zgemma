SRCDATE = "20181121"

require zgemma-libs.inc

SRC_URI[md5sum] = "f6d904fd2207d248d3c0a56279a331d7"
SRC_URI[sha256sum] = "aadee210cb317e7243b0e14fd2bf0d8e26e53d38eb930cf4e6d252c051b6235c"

COMPATIBLE_MACHINE = "h9|i55plus"