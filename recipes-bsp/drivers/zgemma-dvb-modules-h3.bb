KV = "4.10.12"
SRCDATE = "20190411"

require zgemma-dvb-modules.inc

SRC_URI[mips.md5sum] = "19a4c60008dd55194825f69f3398dd44"
SRC_URI[mips.sha256sum] = "65a78b61b6953b5e34e3781742540c41c30cc5e677c817621dfc5378a6beb446"

COMPATIBLE_MACHINE = "h3"