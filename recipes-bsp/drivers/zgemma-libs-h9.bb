SRCDATE = "20171110"

require zgemma-libs.inc

SRC_URI[md5sum] = "caab1333a18b2506072bb070fe86c0bf"
SRC_URI[sha256sum] = "7a7cc9cfc3cea8eb1cbb7ee5def50e23957babb470ea8276ca6e529ef19834a7"

COMPATIBLE_MACHINE = "h9"