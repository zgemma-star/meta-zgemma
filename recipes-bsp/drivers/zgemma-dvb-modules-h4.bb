KV = "4.10.12"
SRCDATE = "20180830"

require zgemma-dvb-modules.inc

SRC_URI[mips.md5sum] = "3cbfb78601cb81bdcb74b6425d78db8b"
SRC_URI[mips.sha256sum] = "f0ee9245be386916932b21cc6a9dd0af84202b3fa662e3dd71a9890f9ac8de79"

COMPATIBLE_MACHINE = "h4"